Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
Time: 2022-09-28T20:06:22
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20170223_1515(x64) - Exporter 18.0.0.420 - Alternate UI 18.0.0.420
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Wed Sep 28 20:06:22 2022 * Host: DESKTOP-RBR1KM2 * Database: C:\Users\andre\AppData\Local\Temp\{C84B0553-391A-45B1-8451-0C5C277FEBE4}\ifc * Database version: 5507 * Database creation date: Wed Sep 28 20:06:22 2022 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Wed Sep 28 20:06:22 2022 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Wed Sep 28 20:06:22 2022 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcSite, Default
RefLatitude: 42, 24, 53, 508911; RefLongitude: -71, -15, -29, -58837; RefElevation: 0 mm
Other - Category: Project Information

# IfcBuilding
Other - Category: Project Information

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: Level 1; Family and Type: Level: Level 1; Type: Level: Level 1; Type Id: Level: Level 1
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Solid; Line Weight: 1; Symbol at End 1 Default: no; Symbol at End 2 Default: yes
Identity Data(Type) - Type Name: Level 1

# IfcFlowTerminal: Floor Light A810, Artek_Lighting_Floor-Light-A810:Floor Light A810:16851
In: Level 1
Type - Material: Black Steel, White Steel, Brass
Type - Constraints - DefaultElevation: 0 mm; NominalVoltageCalc: 0 V
Type - Dimensions - Light Source Symbol Size: 609.6 mm; NominalLength: 480 mm; NominalRadius: 285 mm; NominalWidth: 269.999 mm
Type - General - BIMObjectName: Artek_Lighting_Floor-Light-A810; ManufacturerName: Artek; ManufacturerURL: https://www.artek.fi/; NBSDescription: General purpose luminaires; NBSReference: 90-60-50/405; ProductInformation: This popular floor light features two hand-riveted shades, each formed from delicate, lacquered metal strips. Together they present a striking combination of lines and curves and allow for an interesting interplay of direct and indirect light. The stand is finished in hand-sewn black leather, while the neck has a polished brass collar. Floor Light A810 was created by Alvar Aalto in 1959 for the National Pensions Institute, Helsinki.; Revision: n/a; Uniclass2: Pr_70_70_49_86; Uniclass2015Description: General purpose luminaires; Uniclass2015Reference: Pr_70_70_48_62; Version: 1; VersionDate: 27/09/2022
Type - Identity Data - Collection: Pendant Lights; Description: This popular floor light features two hand-riveted shades, each formed from delicate, lacquered metal strips. Together they present a striking combination of lines and curves and allow for an interesting interplay of direct and indirect light. The stand is finished in hand-sewn black leather, while the neck has a polished brass collar. Floor Light A810 was created by Alvar Aalto in 1959 for the National Pensions Institute, Helsinki.; Designer: Alvar Aalto; Manufacturer: Artek; Model: Floor Light A810; OmniClass Number: 23.80.70.00; OmniClass Title: Lighting; Type Name: Floor Light A810; URL: https://www.artek.fi/en/products/floor-light-a810
Type - Materials and Finishes - LightFixtureMainMaterial: White Steel; LightFixtureSecondaryMaterial: Brass; LightFixtureTertiaryMaterial: Black Steel
Type - Other - AccessibilityPerformance: n/a; AssetType: Movable; Brand: Artek; Category: Lighting; CodePerformance: n/a; Color: White; Constituents: n/a; DurationUnit: Years; ExpectedLife: n/a; Family Name: Artek_Lighting_Floor-Light-A810; Features: Two hand-riveted shades, each formed from delicate, lacquered metal strips; Finish: n/a; Grade: n/a; Material: Base and stand:Steel, covered with leather Tube versions:Brass, Stainless steel Shade:Hand-riveted louvered steel; ModelNumber: 29000401; ModelReference: n/a; Name: Floor-Light-A810; ReplacementCost: n/a; Shape: Sculptured; Size: 485x270x1650 mm; SustainabilityPerformance: n/a; WarrantyDescription: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: Years; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Type - Photometrics - Color Filter: 16777215; Dimming Lamp Color Temperature Shift: <None>; Efficacy: 148.542 s3*lm/kg/m2; Illuminance: 11.8206 lx; Initial Color: 0; Initial Color Temperature: 3000 K; Initial Intensity: 0; Light Loss Factor: 0; Light Source Definition (family): Point+Spherical; Luminous Flux: 1380 lm; Luminous Intensity: 109.817 cd; Total Light Loss Factor: 1; Wattage: 9.2903 W
Constraints - Host: Level : Level 1; Level: Level: Level 1; Offset: 0 mm
Dimensions - Area: 2.53455 m2; NominalHeight: 1650 mm; Volume: 0.451066 m3
Electrical - Circuiting - Electrical Data: 0 V/1-0 VA
Electrical - Lighting - Calculate Coefficient of Utilization: no
Identity Data - Mark: 6
Other - AssetIdentifier: n/a; Barcode: n/a; Category: Lighting Fixtures; Family: Artek_Lighting_Floor-Light-A810: Floor Light A810; Family and Type: Artek_Lighting_Floor-Light-A810: Floor Light A810; InstallationDate: n/a; SerialNumber: n/a; TagNumber: n/a; Type: Artek_Lighting_Floor-Light-A810: Floor Light A810; Type Id: Artek_Lighting_Floor-Light-A810: Floor Light A810; WarrantyStartDate: n/a
Phasing - Phase Created: New Construction
